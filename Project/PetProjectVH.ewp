# IAR project PetProjectVH.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F051R8 ST STM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F051
  ICCARM.CCIncludePath2: ..\Platform\stm32_libs\CMSIS\Device\ST\STM32F0xx\Include; ..\Platform\stm32_libs\STM32F0xx_StdPeriph_Driver\inc; ..\Platform\stm32_conf\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: PetProjectVH.out
  ILINK.IlinkIcfFile: stm32f051_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group boot_loader/src
    ../BootLoader/src/: main.c
  group platform/cmsis
    ../Platform/stm32_libs/CMSIS/Device/ST/STM32F0xx/Source/Templates/iar/: startup_stm32f051.s
    ../Platform/stm32_libs/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group platform/StdPeriph_Driver
    ../Platform/stm32_libs/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
